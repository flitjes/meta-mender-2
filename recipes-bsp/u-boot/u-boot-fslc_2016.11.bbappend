FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://secondary_partition.patch"
